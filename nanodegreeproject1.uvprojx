# Keil uVision project nanodegreeproject1.uvprojx, settings and files
target Target1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nanodegreeproject1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\Appl\Inc;.\Common;.\Config\Inc;.\HAL\Inc;.\SERVICE\Inc;.\Mcal\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Appl
    ./Appl/: main.c
  group Mcal
    ./Mcal/: Dio.c Gpt.c IntCtrl.c Port.c
  group Config
    ./Config/: IntCtrl_Lcfg.c Dio_Lcfg.c Gpt_Lcfg.c Port_Lcfg.c
  group Hal
    ./HAL/: Led.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
